Commit message: Optimization based grasping.

File: ur5/UR5e.urdf (robot description, URDF)
Before this commit: robot ur5e, 13 links, 12 joints
Links:
- added link tcp
Joints:
- added joint tool0-tcp: type fixed, parent tool0, child tcp, origin xyz=0 -0.05753 -0.10 rpy=0 0 0
